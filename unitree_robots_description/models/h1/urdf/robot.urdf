Commit message: added g1

File: unitree_robots_description/models/h1/urdf/robot.urdf (robot description, URDF)
Before this commit: robot h1, 52 links, 51 joints
Links:
- added link base_link
Joints:
- added joint floating_base_joint: type fixed, parent base_link, child pelvis
